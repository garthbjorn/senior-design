# Keil uVision project RTX_Blinky.uvprojx, settings and files
target STM32F051 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Files
    ./: RTX_Blinky.c f0_usart.c f0_usart.h vt100.h stm32f0xx_adc.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_adc.h stm32f0xx_gpio.h stm32f0xx_rcc.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx.h stm32f0xx_conf.h f0_adc.c display.c stm32f0xx_misc.c stm32f0xx_misc.h f0_adc.h
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 1.5.0
